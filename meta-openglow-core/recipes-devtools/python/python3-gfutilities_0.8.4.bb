inherit pypi setuptools3
require python-gfutilities.inc
