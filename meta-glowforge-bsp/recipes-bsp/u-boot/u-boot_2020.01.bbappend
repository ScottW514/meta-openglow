require u-boot-glowforge-common_${PV}.inc

DEPENDS += "u-boot-mkimage-native"
