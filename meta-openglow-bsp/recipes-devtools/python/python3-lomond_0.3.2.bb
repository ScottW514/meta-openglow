inherit pypi setuptools3
require python-lomond.inc
