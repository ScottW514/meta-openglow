PACKAGECONFIG = "jpeg"
COMPATIBLE_MACHINE = "openglow_std"
