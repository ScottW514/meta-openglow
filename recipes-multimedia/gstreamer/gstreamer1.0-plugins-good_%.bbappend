PACKAGECONFIG = "jpeg"
